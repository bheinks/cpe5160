# Keil uVision project cpe5160.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: cpe5160 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c LCD.c main.c UART.c AT89C51RC2.h delay.h LCD.h main.h UART.h PORT.h
